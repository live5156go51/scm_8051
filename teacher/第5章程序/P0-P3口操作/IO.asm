		ORG		0000H
		AJMP	MAIN
		ORG		0030H
MAIN:	SETB	P1.4
		SETB	P1.5
		MOV		R0,#50

LOOP:	MOV		B,R0
		CPL		P2.0
		ACALL	DELAY
		JB		P1.4,NEXT
		ACALL	KEYDL
		JB		P1.4,NEXT
		INC		R0
		INC		R0
		INC		R0
		INC		R0
		INC		R0
		INC		R0
NEXT:	JB		P1.5,LOOP
		ACALL	KEYDL
		JB		P1.5,LOOP
		DEC		R0
		DEC		R0
		DEC		R0
		DEC		R0
		DEC		R0
		DEC		R0				
		SJMP	LOOP

DELAY:	
DP1:	MOV		R1,#01H
DP2:	MOV		R2,#0FH
		DJNZ	R2,$
		DJNZ	R1,DP2
		DJNZ	B,DP1
		RET

KEYDL:	MOV		30H,#9FH
KEYDL1:	MOV		31H,#0FFH
		DJNZ	31H,$
		DJNZ	30H,KEYDL1			
		RET

		END