		ORG		0000H
		AJMP	MAIN
		ORG		0030H

MAIN:	MOV		P1,#0FFH
		MOV		DPTR,#TAB
		MOV		R0,#05H
		

LOOP:	MOV		A,R0
		MOVC	A,@A+DPTR
		MOV		P2,A
		ACALL	DELAY
		INC		R0	
		CJNE	R0,#11,LOOP
		MOV		R0,#00H
		SJMP	LOOP

DELAY:	MOV		B,#5
DP1:	MOV		R1,#0FFH
DP2:	MOV		R2,#0FFH
		DJNZ	R2,$
		DJNZ	R1,DP2
		DJNZ	B,DP1
		RET

		ORG		0100H
TAB:	DB	0xC0,0xF9,0xA4,0xB0,0x99,0x92,0x82,0xF8,0x80,0x90
		DB	0x88,0x83,0xC6,0xA7,0xA1,0x86,0xBF,0FFH
		END